# Keil uVision project iSO-STM32.uvproj, settings and files
target WF-ESP8266 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Template +hex
  AfterMake: D:\keil4\ARM\ARMCC\bin\fromelf.exe  --bin -o  ..\..\Output\Template.bin ..\..\Output\Template.axf
  c flags: Optim=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\gpio;..\..\User\SysTick;..\..\User\usart;..\..\User\wifi;..\..\hardware\COUNTSPEED;..\..\hardware\DHT11;..\..\hardware\HC-SR501;..\..\hardware\MOTOR;..\..\hardware\OV7670;..\..\hardware\TFTLCD;..\..\hardware\TIMER;..\..\hardware\MALLOC;..\..\hardware\EXTI
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ../../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
    ../../User/usart/: bsp_usart1.c bsp_usart2.c
    ../../User/gpio/: bsp_gpio.c
    ../../User/SysTick/: bsp_SysTick.c
    ../../User/wifi/: wifi_config.c wifi_function.c
  group HARDWARE
    ../../hardware/COUNTSPEED/: countspeed.c
    ../../hardware/DHT11/: dht11.c
    ../../hardware/EXTI/: exti.c
    ../../hardware/HC-SR501/: HC-SR501.c
    ../../hardware/MOTOR/: motor.c
    ../../hardware/OV7670/: ov7670.c sccb.c
    ../../hardware/TFTLCD/: ILI93xx.c
    ../../hardware/MALLOC/: malloc.c
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group DOC
    ../../Doc/: readme.txt
